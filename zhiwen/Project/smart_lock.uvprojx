# Keil uVision project smart_lock.uvprojx, settings and files
target smart_lock (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart_lock
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\STM32F10x_FWLib\inc;..\Sys\delay;..\Sys\sys;..\Project;..\Project;..\User\BF5325A;..\User\KEY;..\User\LED;..\Sys\usart;..\User\TIMER;..\User\OLED;..\User\UI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Project
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rcc.c
  group Ssy
    ../Sys/delay/: delay.c
    ../Sys/sys/: sys.c
    ../Sys/usart/: usart.c
  group User
    ../User/BF5325A/: BF5325A.c
    ../User/KEY/: key.c
    ../User/LED/: led.c
    ../User/TIMER/: timer.c
    ../User/OLED/: LQ12864.c
    ../User/UI/: ui.c
